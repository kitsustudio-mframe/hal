# Keil uVision project hal.uvprojx, settings and files
target hal (6160000::V6.16::ARMCLANG)
  device: -AT32F415RBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.8
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: hal (library)
  AfterMake: .keil\copy.bat bsp_arterytek_at32f415.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: AnalogInputPin.h AnalogInputPort.h Base.h GeneralInput.h GeneralOutput.h GeneralPin.h GeneralPinMode.h GeneralPort.h InterruptEvent.h package-info.h
  group src/timer
    ./timer/: EventCancel.h EventTrigger.h package-info.h Timer.h
  group src/tigger
    ./trigger/: EdgeTrigger.h EventFall.h EventRise.h package-info.h
  group src/usart
    ./usart/: EventReceiver.h EventTransfer.h package-info.h USART.h
